Commit message: 3Dモデルの修正

File: megarover_sim/urdf/megarover.urdf (robot description, URDF)
Before this commit: robot megarover, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://megarover_sim/dae/megarover.dae
